# Repository dienbk7x/ITEADHW_4-20mA-Sensor-Brick

## KiCad design tute1.kicad_pcb

Parts:
C1: 103
C2, C3, C4: 10u
C5: 0.1u
D1: 1N5819
L1: 10uH
P1, P2, P3: CONN_2
P4, P5: HEADER_2
P6: CONN_4
P7: UCONN_4
R1, R2: 100; 0805
R3, R4, R5, R6: 10k
R7, R8, R9, R10: 20k
R11: 3.3k
R12: 62k
U1: LMH6643
U2: MP3212

Connections:
+5V: C1.1, C2.1, C3.2, C5.2, P6.2, P7.2, U1.8 (V+), U2.3 (VDD)
+24V: C4.2, D1.2 (K), P1.1, R12.1, U2.9 (VOut)
AGND: C1.2, C2.2, C3.1, C4.1, C5.1, P1.2 (PM), P4.2 (PM), P5.2 (PM), P6.1, P7.1, R7.2, R8.2, R11.2, U1.4 (V-), U2.1 (PGND), U2.7 (AGND), U2.8 (SHDN)
unnamed: R11.1, R12.2, U2.5 (FB)
unnamed: L1.1, U2.2 (VDDO)
unnamed: D1.1 (A), L1.2, U2.10 (SW)
unnamed: R4.1, R10.1, U1.6 (-)
unnamed: P6.4, P7.4, R10.2, U1.7
unnamed: P6.3, P7.3, R9.2, U1.1
unnamed: R3.1, R9.1, U1.2 (-)
unnamed: P3.1, R2.1, R6.2
unnamed: P3.2 (PM), P5.1, R2.2, R4.2
unnamed: P2.2 (PM), P4.1, R1.2, R3.2
unnamed: P2.1, R1.1, R5.2
unnamed: R5.1, R7.1, U1.3 (+)
unnamed: R6.1, R8.1, U1.5 (+)

Board: 2 copper layers, 40.6 x 29.0 mm, 28 parts (0 on the bottom side), 16 nets.

## Commit log

2014-09-26 1.0
    1.0
